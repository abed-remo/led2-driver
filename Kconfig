## Kconfig
```kconfig
menuconfig LED2_DRIVER
    tristate "LED2 Character Device Driver"
    default m
```
